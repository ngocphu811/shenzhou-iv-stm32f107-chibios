# Keil uVision project ch.uvproj, settings and files
target Demo (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ch
  c flags: Optim=4 oTime=1
  c define: __heap_base__=Image$$RW_IRAM1$$ZI$$Limit __heap_end__=Image$$RW_IRAM2$$Base
  c include: ..\;..\..\common;..\..\..\ext\STM32F10x_StdPeriph_Driver\inc;..\..\..\os\kernel\include;..\..\..\os\ports\common\ARMCMx;..\..\..\os\ports\RVCT\ARMCMx;..\..\..\os\ports\RVCT\ARMCMx\STM32F1xx;..\..\..\os\hal\include;..\..\..\os\hal\platforms\STM32;..\..\..\os\hal\platforms\STM32F1xx;..\..\..\os\hal\platforms\STM32\GPIOv1;..\..\..\os\hal\platforms\STM32\DMAv1;..\..\..\ext\STM32_ETH_Driver\inc;..\..\..\os\various\lwip_bindings;..\..\..\ext\lwip-1.4.0\src\include;..\..\..\ext\lwip-1.4.0\src\include\ipv4;..\..\..\os\various;..\..\..\boards\shenzhou_iv_net;..\..\..\test
  asm misc: --cpreproc
  asm include: ..\;..\..\..\boards\shenzhou_iv_net;..\..\..\os\ports\RVCT\ARMCMx\STM32F1xx
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x1
  group board
    ../../../boards/shenzhou_iv_net/: board.c board.h
  group port
    ../../../os/ports/RVCT/ARMCMx/: cstartup.s chcoreasm_v7m.s chcore.c chcore_v7m.c chcore.h chcore_v7m.h chtypes.h
    ../../../os/ports/common/ARMCMx/: nvic.c nvic.h
    ../../../os/ports/RVCT/ARMCMx/STM32F1xx/: vectors.s
  group kernel
    ../../../os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
    ../../../os/kernel/include/: ch.h chbsem.h chcond.h chdebug.h chdynamic.h chevents.h chfiles.h chheap.h chinline.h chlists.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstreams.h chsys.h chthreads.h chvt.h
  group hal
    ../../../os/hal/src/: adc.c can.c gpt.c hal.c i2c.c mac.c mmc_spi.c pal.c pwm.c serial.c serial_usb.c spi.c uart.c usb.c ext.c icu.c rtc.c sdc.c tm.c
    ../../../os/hal/include/: adc.h can.h gpt.h hal.h i2c.h mac.h mii.h mmc_spi.h pal.h pwm.h serial.h serial_usb.h spi.h uart.h usb.h ext.h icu.h rtc.h sdc.h usb_cdc.h
  group platform
    ../../../os/hal/platforms/STM32/: serial_lld.h serial_lld.c mac_lld.c mac_lld.h
    ../../../os/hal/platforms/STM32/GPIOv1/: pal_lld.h pal_lld.c
    ../../../os/hal/platforms/STM32F1xx/: stm32f10x.h hal_lld.c hal_lld.h hal_lld_f100.h hal_lld_f103.h hal_lld_f105_f107.h stm32_rcc.h stm32_dma.c stm32_dma.h
  group test
    ../../../test/: test.c testbmk.c testdyn.c testevt.c testheap.c testmbox.c testmsg.c testmtx.c testpools.c testqueues.c testsem.c testthd.c test.h testbmk.h testdyn.h testevt.h testheap.h testmbox.h testmsg.h testmtx.h testpools.h testqueues.h testsem.h testthd.h
  group lwipbind
    ../../../os/various/lwip_bindings/: lwipthread.c lwipthread.h
    ../../../os/various/lwip_bindings/arch/: sys_arch.c sys_arch.h
    ../../../os/various/: evtimer.c evtimer.h
  group lwipcore
    ../../../ext/lwip-1.4.0/src/netif/: etharp.c
    ../../../ext/lwip-1.4.0/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group lwipipv4
    ../../../ext/lwip-1.4.0/src/core/: def.c timers.c
    ../../../ext/lwip-1.4.0/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwipapi
    ../../../ext/lwip-1.4.0/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group demo
    ../: main.c chconf.h halconf.h mcuconf.h lwipopts.h
    ../web/: web.c web.h
  group common
    ../../common/: board_led.c board_led.h
  group StdPeriphLib
    ../../../ext/STM32_ETH_Driver/src/: stm32_eth.c
    ../../../ext/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
